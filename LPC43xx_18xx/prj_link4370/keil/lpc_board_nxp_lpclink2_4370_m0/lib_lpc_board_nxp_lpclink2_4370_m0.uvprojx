# Keil uVision project lib_lpc_board_nxp_lpclink2_4370_m0.uvprojx, settings and files
target nxp_lpclink2_4370_m0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4370:Cortex-M0 Sub NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IRAM(0x10000000,0x20000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lib_lpc_board_nxp_lpclink2_4370_m0 (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\chip_43xx_18xx\inc;..\..\..\brd_link4370\inc;..\..\..\chip_43xx_18xx\config_43xx_m0app
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../brd_link4370/src/: board.c board_sysinit.c
