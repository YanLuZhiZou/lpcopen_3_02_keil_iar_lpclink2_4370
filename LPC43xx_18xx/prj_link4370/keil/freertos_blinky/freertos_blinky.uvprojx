# Keil uVision project freertos_blinky.uvprojx, settings and files
target spifi_nxp_lpclink2_4370 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4370:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IRAM(0x10000000,0x20000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_blinky
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\examples_43xx_18xx\freertos_blinky\inc;
..\..\..\chip_43xx_18xx\inc;
..\..\..\chip_43xx_18xx\config_43xx;
..\..\..\brd_link4370\inc;
..\..\..\..\freertos\freertos\Source\include;
..\..\..\..\freertos\freertos\Source\portable\RVDS\ARM_CM4F;
  memory RVCT4: ROM 0x14000000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../chip_43xx_18xx/startup/: sysinit.c keil_freertos_startup_lpc18xx43xx.s
    ../../../examples_43xx_18xx/freertos_blinky/src/: freertos_blinky.c
  group freertos
    ../../../../freertos/freertos/Source/: list.c queue.c tasks.c timers.c
    ../../../../freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../examples_43xx_18xx/freertos_blinky/: readme.txt
  group lib
    ../lpc_board_nxp_lpclink2_4370/keil_output/core_m4/: lib_lpc_board_nxp_lpclink2_4370.lib
    ../lpc_chip_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
