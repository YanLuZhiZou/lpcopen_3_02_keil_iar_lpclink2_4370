# Keil uVision project i2cm_interrupt.uvprojx, settings and files
target spifi_nxp_lpclink2_4370 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4330 NXP (founded by Philips)
  pack: Keil.LPC4300_DFP.2.8.0
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: i2cm_interrupt
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\chip_43xx_18xx\inc;
..\..\..\chip_43xx_18xx\config_43xx;
..\..\..\brd_link4370\inc;
  asm define: CORE_M4
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../chip_43xx_18xx/startup/: sysinit.c keil_startup_lpc18xx43xx.s
    ../../../examples_43xx_18xx/periph_i2cm_interrupt/src/: i2cm_interrupt.c
    ../../../examples_43xx_18xx/periph_i2cm_interrupt/: readme.txt
  group lib
    ../lpc_chip_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
    ../lpc_board_nxp_lpclink2_4370/keil_output/core_m4/: lib_lpc_board_nxp_lpclink2_4370.lib
