# Keil uVision project multicore_blinky_m4.uvprojx, settings and files
target spifi_nxp_lpclink2_4370 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4330 NXP (founded by Philips)
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: multicore_blinky_m4
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CORE_M4
  c include: ..\..\..\chip_43xx_18xx\config_43xx;
..\..\..\chip_43xx_18xx\inc;
..\..\..\brd_link4370\inc;
..\..\..\examples_43xx_18xx\multicore_common;
..\..\..\examples_43xx_18xx\multicore_blinky_m4\inc;
  memory RVCT4: ROM 0x14000000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../examples_43xx_18xx/multicore_common/: ipc_example.c ipc_msg.c m0_img_ldr.c
    ../../../examples_43xx_18xx/multicore_blinky_m4/src/: blinky_m4.c
    ../../../chip_43xx_18xx/startup/: keil_startup_lpc18xx43xx.s sysinit.c
  group lib
    ../lpc_board_nxp_lpclink2_4370/keil_output/core_m4/: lib_lpc_board_nxp_lpclink2_4370.lib
    ../lpc_chip_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
