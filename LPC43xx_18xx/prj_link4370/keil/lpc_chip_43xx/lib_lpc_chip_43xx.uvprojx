# Keil uVision project lib_lpc_chip_43xx.uvprojx, settings and files
target lib_chip_43xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4350:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.8.0
  cpu: IRAM(0x10000000,0x20000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib_lpc_chip_43xx (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\chip_43xx_18xx\inc;..\..\..\chip_43xx_18xx\config_43xx;..\..\..\brd_link4370\inc
  asm define: CORE_M4
  memory RVCT4: ROM 0x14000000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../chip_43xx_18xx/src/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c chip_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c eeprom_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c hsadc_18xx_43xx.c i2c_18xx_43xx.c i2cm_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c otp_18xx_43xx.c pmc_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c sct_pwm_18xx_43xx.c sdif_18xx_43xx.c sdmmc_18xx_43xx.c spi_18xx_43xx.c ssp_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c sysinit_18xx_43xx.c gpiogroup_18xx_43xx.c pinint_18xx_43xx.c iap_18xx_43xx.c stopwatch_18xx_43xx.c
  group common
    ../../../chip_43xx_18xx/src/: fpu_init.c ring_buffer.c
