# Keil uVision project multicore_blinky_m0app.uvprojx, settings and files
target iflash_nxp_lpclink2_4370 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC4370:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IRAM(0x10000000,0x20000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: multicore_blinky_m0app
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0 LPC43XX_CORE_M0APP
  c include: ..\..\..\chip_43xx_18xx\config_43xx;
..\..\..\chip_43xx_18xx\config_43xx_m0app;
..\..\..\chip_43xx_18xx\inc;
..\..\..\brd_link4370\inc;
..\..\..\examples_43xx_18xx\multicore_common;
..\..\..\examples_43xx_18xx\multicore_blinky_m0\inc;
  memory RVCT4: ROM 0x10080000 size 0x12000
  memory RVCT9: RAM 0x20008000 size 0x8000
  group src
    ../../../examples_43xx_18xx/multicore_common/: ipc_example.c ipc_msg.c
    ../../../chip_43xx_18xx/startup/: sysinit.c keil_startup_lpc43xx_m0app.s
    ../../../examples_43xx_18xx/multicore_blinky_m0/src/: blinky_m0.c
  group lib
    ../lpc_chip_43xx_m0/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
    ../lpc_board_nxp_lpclink2_4370_m0/keil_output/core_m0/: lib_lpc_board_nxp_lpclink2_4370_m0.lib
