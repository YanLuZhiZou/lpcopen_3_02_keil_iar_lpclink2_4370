<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lpc_board_nxp_lpclink2_4370\lib_lpc_board_nxp_lpclink2_4370.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lpc_chip_43xx\lib_lpc_chip_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_atimer\atimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cm_interrupt\i2cm_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cm_polling\i2cm_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\misc_spifi_tst\spifi_tst.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_timers\timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_grouped_int\grouped_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_hsadc\hsadc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2c\i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pinint\pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_ritimer\ritimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_rtc\rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_sct_pwm\sct_pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_ssp\ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_systick\systick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart\uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart_rb\uart_rb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_watchdog\watchdog.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>test</name>
      <member>
        <project>lib_lpc_board_nxp_lpclink2_4370</project>
        <configuration>nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>lib_lpc_chip_43xx</project>
        <configuration>chip_43xx_lib</configuration>
      </member>
      <member>
        <project>atimer</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>grouped_int</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>hsadc</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>i2c</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>i2cm_interrupt</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>i2cm_polling</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>pinint</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>ritimer</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>rtc</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>sct_pwm</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>ssp</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>systick</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>uart</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>uart_rb</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>spifi_tst</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


