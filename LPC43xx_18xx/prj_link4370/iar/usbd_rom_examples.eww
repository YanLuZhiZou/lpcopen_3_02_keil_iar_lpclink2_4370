<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lpc_chip_43xx\lib_lpc_chip_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lpc_board_nxp_lpclink2_4370\lib_lpc_board_nxp_lpclink2_4370.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_bwtest\bwtest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_cdc_uart\cdc_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_cdc_vcom\cdc_vcom.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_dfu_composite\dfu_composite.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_hid_generic\hid_generic.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_hid_keyboard\hid_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_hid_mouse\hid_mouse.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_hid_sio\hid_sio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_libusbdev\libusbdev.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rom_msc_ram\msc_ram.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>test</name>
      <member>
        <project>lib_lpc_chip_43xx</project>
        <configuration>chip_43xx_lib</configuration>
      </member>
      <member>
        <project>lib_lpc_board_nxp_lpclink2_4370</project>
        <configuration>nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>bwtest</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>cdc_uart</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>cdc_vcom</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>dfu_composite</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>hid_generic</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>hid_keyboard</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>hid_mouse</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>hid_sio</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>libusbdev</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
      <member>
        <project>msc_ram</project>
        <configuration>spifi_nxp_lpclink2_4370</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


