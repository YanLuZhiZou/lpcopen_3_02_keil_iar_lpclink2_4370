# IAR project lib_lpc_chip_43xx.ewp, settings and files
configuration chip_43xx_lib (ARM, debug)
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; CORE_M4
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\chip_43xx_18xx\inc; ..\..\..\chip_43xx_18xx\config_43xx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_lpc_chip_43xx.out
  group common
    ../../../chip_43xx_18xx/src/: fpu_init.c ring_buffer.c
  group src
    ../../../chip_43xx_18xx/src/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c chip_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c eeprom_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c gpiogroup_18xx_43xx.c hsadc_18xx_43xx.c i2c_18xx_43xx.c i2cm_18xx_43xx.c i2s_18xx_43xx.c iap_18xx_43xx.c lcd_18xx_43xx.c otp_18xx_43xx.c pinint_18xx_43xx.c pmc_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c sct_pwm_18xx_43xx.c sdif_18xx_43xx.c sdmmc_18xx_43xx.c spi_18xx_43xx.c ssp_18xx_43xx.c stopwatch_18xx_43xx.c sysinit_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c
