# IAR project multicore_blinky_m4.ewp, settings and files
configuration spifi_nxp_lpclink2_4370 (ARM)
  General.OGChipSelectEditMenu: LPC4370_M4 NXP LPC4370_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ..\..\..\brd_link4370\inc; ..\..\..\chip_43xx_18xx\inc; ..\..\..\chip_43xx_18xx\config_43xx; ..\..\..\examples_43xx_18xx\multicore_common; ..\..\..\examples_43xx_18xx\multicore_blinky_m4\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: timers.srec
  ILINK.IlinkOutputFile: blinky_m4.out
  ILINK.IlinkIcfFile: ..\..\..\chip_43xx_18xx\tool_configs\iar_linker_scripts\lpc18xx_43xx_ldscript_spifi.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../examples_43xx_18xx/multicore_blinky_m4/: readme.txt
  group lib
    ../lpc_board_nxp_lpclink2_4370/iar_output/Exe/: lib_lpc_board_nxp_lpclink2_4370.a
    ../lpc_chip_43xx/iar_output/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../examples_43xx_18xx/multicore_blinky_m4/src/: blinky_m4.c
    ../../../chip_43xx_18xx/startup/: iar_startup_lpc18xx43xx.s sysinit.c
    ../../../examples_43xx_18xx/multicore_common/: ipc_example.c ipc_msg.c m0_img_ldr.c
