# IAR project lib_lpc_board_nxp_lpclink2_4370.ewp, settings and files
configuration nxp_lpclink2_4370 (ARM)
  General.OGChipSelectEditMenu: LPC4370_M4 NXP LPC4370_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\chip_43xx_18xx\inc; ..\..\..\chip_43xx_18xx\config_43xx; ..\..\..\brd_link4370\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  ILINK.IlinkOutputFile: lib_lpc_board_nxp_lpclink2_4370.out
  group src
    ../../../brd_link4370/src/: board.c board_sysinit.c
