# IAR project multicore_blinky_m0sub.ewp, settings and files
configuration spifi_nxp_lpclink2_4370 (ARM)
  General.OGChipSelectEditMenu: LPC4370_M0 NXP LPC4370_M0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ..\..\..\brd_link4370\inc; ..\..\..\chip_43xx_18xx\inc; ..\..\..\chip_43xx_18xx\config_43xx_m0sub; ..\..\..\examples_43xx_18xx\multicore_common; ..\..\..\examples_43xx_18xx\multicore_blinky_m0\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: timers.srec
  ILINK.IlinkOutputFile: blinky_m0sub.out
  ILINK.IlinkIcfFile: ..\..\..\chip_43xx_18xx\tool_configs\iar_linker_scripts\lpc43xx_m0sub_ldscript_spifi.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../examples_43xx_18xx/multicore_blinky_m0/: readme.txt
  group lib
    ../lpc_board_nxp_lpclink2_4370_m0/iar_output_m0/Exe/: lib_lpc_board_nxp_lpclink2_4370_m0.a
    ../lpc_chip_43xx_m0/iar_output/Exe/: lib_lpc_chip_43xx_m0.a
  group src
    ../../../examples_43xx_18xx/multicore_blinky_m0/src/: blinky_m0.c
    ../../../chip_43xx_18xx/startup/: iar_startup_lpc43xx_m0sub.s sysinit.c
    ../../../examples_43xx_18xx/multicore_common/: ipc_example.c ipc_msg.c
