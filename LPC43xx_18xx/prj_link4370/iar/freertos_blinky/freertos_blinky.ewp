# IAR project freertos_blinky.ewp, settings and files
configuration spifi_nxp_lpclink2_4370 (ARM)
  General.OGChipSelectEditMenu: LPC4370_M4 NXP LPC4370_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\brd_link4370\inc; ..\..\..\chip_43xx_18xx\inc; ..\..\..\chip_43xx_18xx\config_43xx; ../../../../freertos/freertos/Source/portable/IAR/ARM_CM4F; ../../../../freertos/freertos/Source/include; ..\..\..\examples_43xx_18xx\freertos_blinky\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  AARM.AUserIncludes: ..\..\..\examples_43xx_18xx\freertos_blinky\inc
  OBJCOPY.OOCOutputFile: blinky.srec
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: ..\..\..\chip_43xx_18xx\tool_configs\iar_linker_scripts\lpc18xx_43xx_spifi_heap.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../examples_43xx_18xx/freertos_blinky/: readme.txt
  group lib
    ../lpc_board_nxp_lpclink2_4370/iar_output/Exe/: lib_lpc_board_nxp_lpclink2_4370.a
    ../lpc_chip_43xx/iar_output/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../examples_43xx_18xx/freertos_blinky/src/: freertos_blinky.c
    ../../../chip_43xx_18xx/startup/: iar_startup_lpc18xx43xx.s sysinit.c
  group src/freertos
    ../../../../freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../freertos/freertos/Source/: list.c queue.c tasks.c
    ../../../../freertos/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
